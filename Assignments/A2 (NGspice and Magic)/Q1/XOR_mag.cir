* SPICE3 file created from XOR.ext - technology: scmos

.option scale=0.09u
.include TSMC_180nm.txt
.global GND Gnd

Va A 0 PULSE(0 1.8 0 100p 100p 10n 20n)
Vb B 0 PULSE(0 1.8 0 100p 100p 20n 40n)

Vdd VDD 0 dc 1.8

* SPICE3 file created from XOR.ext - technology: scmos

.option scale=0.09u

M1000 VDD OR_2_0/a_n35_n16# OUT OR_2_0/w_40_n2# CMOSP w=15 l=5
+  ad=1602 pd=536 as=135 ps=48
M1001 OR_2_0/a_n35_n16# m1_65_n48# GND Gnd CMOSN w=15 l=5
+  ad=210 pd=88 as=1287 ps=448
M1002 OR_2_0/a_n35_n16# m1_65_n48# OR_2_0/a_n35_5# OR_2_0/w_n1_n2# CMOSP w=15 l=5
+  ad=135 pd=48 as=270 ps=96
M1003 OUT OR_2_0/a_n35_n16# GND Gnd CMOSN w=15 l=5
+  ad=105 pd=44 as=0 ps=0
M1004 VDD m1_68_43# OR_2_0/a_n35_5# OR_2_0/w_n42_n2# CMOSP w=15 l=5
+  ad=0 pd=0 as=0 ps=0
M1005 OR_2_0/a_n35_n16# m1_68_43# GND Gnd CMOSN w=15 l=5
+  ad=0 pd=0 as=0 ps=0
M1006 m1_n97_39# A GND Gnd CMOSN w=14 l=4
+  ad=126 pd=46 as=0 ps=0
M1007 VDD A m1_n97_39# CMOS_in_0/w_0_0# CMOSP w=14 l=4
+  ad=0 pd=0 as=126 ps=46
M1008 VDD m1_n97_39# AND_2_0/a_9_10# AND_2_0/w_n1_1# CMOSP w=20 l=7
+  ad=0 pd=0 as=360 ps=116
M1009 AND_2_0/a_9_10# m1_n97_39# AND_2_0/a_10_n33# Gnd CMOSN w=18 l=7
+  ad=180 pd=56 as=360 ps=112
M1010 VDD AND_2_0/a_9_10# m1_68_43# AND_2_0/w_101_1# CMOSP w=20 l=7
+  ad=0 pd=0 as=180 ps=58
M1011 AND_2_0/a_10_n33# B GND Gnd CMOSN w=18 l=7
+  ad=0 pd=0 as=0 ps=0
M1012 VDD B AND_2_0/a_9_10# AND_2_0/w_50_1# CMOSP w=20 l=7
+  ad=0 pd=0 as=0 ps=0
M1013 m1_68_43# AND_2_0/a_9_10# GND Gnd CMOSN w=18 l=7
+  ad=180 pd=56 as=0 ps=0
M1014 VDD m1_n101_n52# AND_2_1/a_9_10# AND_2_1/w_n1_1# CMOSP w=20 l=7
+  ad=0 pd=0 as=360 ps=116
M1015 AND_2_1/a_9_10# m1_n101_n52# AND_2_1/a_10_n33# Gnd CMOSN w=18 l=7
+  ad=180 pd=56 as=360 ps=112
M1016 VDD AND_2_1/a_9_10# m1_65_n48# AND_2_1/w_101_1# CMOSP w=20 l=7
+  ad=0 pd=0 as=180 ps=58
M1017 AND_2_1/a_10_n33# A GND Gnd CMOSN w=18 l=7
+  ad=0 pd=0 as=0 ps=0
M1018 VDD A AND_2_1/a_9_10# AND_2_1/w_50_1# CMOSP w=20 l=7
+  ad=0 pd=0 as=0 ps=0
M1019 m1_65_n48# AND_2_1/a_9_10# GND Gnd CMOSN w=18 l=7
+  ad=180 pd=56 as=0 ps=0
M1020 m1_n101_n52# B GND Gnd CMOSN w=14 l=4
+  ad=126 pd=46 as=0 ps=0
M1021 VDD B m1_n101_n52# CMOS_in_1/w_0_0# CMOSP w=14 l=4
+  ad=0 pd=0 as=126 ps=46
C0 GND Gnd 2.01fF

.tran 10u 120n

*for A
.measure tran triseA
+ TRIG v(A) VAL = 0.9 RISE =1
+ TARG v(OUT) VAL = 0.9 RISE =1

.measure tran tfallA
+ TRIG v(A) VAL = 0.9 RISE =1
+ TARG v(OUT) VAL = 0.9 FALL =1

.measure tran tpd param = '(triseA + tfallA)/2' goal = 0

*for B
.measure tran triseB
+ TRIG v(B) VAL = 0.9 RISE =1
+ TARG v(OUT) VAL = 0.9 RISE =1

.measure tran tfallB
+ TRIG v(B) VAL = 0.9 RISE =1
+ TARG v(OUT) VAL = 0.9 FALL =1

.measure tran tpd param = '(triseB + tfallB)/2' goal = 0

.control
run
plot v(OUT)
* v(A) v(B)
.endc

.end
